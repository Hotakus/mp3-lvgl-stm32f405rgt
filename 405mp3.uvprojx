# Keil uVision project 405mp3.uvprojx, settings and files
target f405mp3 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: 405mp3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,
  c include: core;inc;lib\inc;main;third_party\ff14\source;driver\dma;driver\nvic;driver\sdio;driver\systicks;driver\tim;driver\usart;driver\led;driver\spi;driver\w25qxx;driver\rtc;.\driver\screen\lcd_144_st7735;.\third_party\rt-thread-sorted\finsh;.\third_party\rt-thread-sorted\include;.\third_party\rt-thread-sorted\include\libc;.\third_party\rt-thread-sorted
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ./core/: stm32f4xx_it.c system_stm32f4xx.c
    ./core/startup/: startup_stm32f40_41xxx.s
  group inc
    ./inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h pro_conf.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group lib
    ./lib/: arm_cortexM4lf_math.lib
  group main
    ./main/: main.c main.h
  group stdperiphal
    ./lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group driver
    ./driver/dma/: dma_conf.c
    ./driver/led/: led.c
    ./driver/nvic/: isr_funcs.c nvic_conf.c
    ./driver/rtc/: rtc.c
    ./driver/sdio/: sd_sdio.c sd_sdio_conf.c
    ./driver/spi/: spi_conf.c
    ./driver/systicks/: systick.c
    ./driver/usart/: usart.c
    ./driver/w25qxx/: w25qxx.c
  group fatfs
    ./third_party/ff14/source/: diskio.c diskio.h ff.c ff.h ff_user.c ff_user.h ffconf.h ffsystem.c ffunicode.c
  group rtthread/finsh
    ./third_party/rt-thread-sorted/finsh/: cmd.c msh.c shell.c
  group rtthread/kernal
    ./third_party/rt-thread-sorted/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./third_party/rt-thread-sorted/: cpuport.c context_rvds.S
  group rtthread/user
    ./third_party/rt-thread-sorted/: board.c rtconfig.h
