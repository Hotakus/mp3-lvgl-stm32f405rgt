# Keil uVision project MP3_F405.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MP3_F405 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c misc: --locale=english
  c include: .\main;.\include;.\include\cmsis;.\include\machine;.\include\math;.\lib\STM32F4xx_HAL_Driver\Inc;.\lib\STM32F4xx_HAL_Driver\Inc\Legacy;.\thirdParty\ff14\source;.\thirdParty\rt-thread-nano-sorted;.\thirdParty\rt-thread-nano-sorted\finsh;.\thirdParty\rt-thread-nano-sorted\include;.\thirdParty\rt-thread-nano-sorted\include\libc;.\driver\spi;.\driver\uart;.\driver\tim;.\driver\rtc;.\driver\sdio;.\driver\w25qxx;.\driver\screen;.\driver\screen\lcd_st7789;.\driver\screen\lcd_st7735;.\driver\file_thrans_with_fatfs;.\thirdParty\lvgl;.\thirdParty\lvgl\lvgl;.\thirdParty\lvgl\lvgl\porting;.\thirdParty\lvgl\lvgl\user;.\thirdParty\lvgl\lvgl\src;.\thirdParty\lvgl\lvgl\src\lv_core;.\thirdParty\lvgl\lvgl\src\lv_draw;.\thirdParty\lvgl\lvgl\src\lv_font;.\thirdParty\lvgl\lvgl\src\lv_gpu;.\thirdParty\lvgl\lvgl\src\lv_hal;.\thirdParty\lvgl\lvgl\src\lv_misc;.\thirdParty\lvgl\lvgl\src\lv_themes;.\thirdParty\lvgl\lvgl\src\lv_widgets;.\app;.\app\app_ui;.\driver\sensor\SHT;.\driver\iic;.\driver\vs10xx;.\driver\vs10xx\decode;.\driver\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project\obj\MP3_F405.sct
  group core
    ./core/startup/: startup_stm32f405xx.s
    ./core/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group driver
    ./driver/uart/: uart.c
    ./driver/spi/: spi_conf.c
    ./driver/w25qxx/: w25qxx.c
    ./driver/screen/: screen_conf.c
    ./driver/screen/lcd_st7735/: lcd_st7735.c
    ./driver/screen/lcd_st7789/: lcd_st7789.c
    ./driver/sdio/: sdio.c
    ./driver/file_thrans_with_fatfs/: file_trans.c
    ./driver/tim/: tim.c
    ./driver/rtc/: rtc.c
    ./driver/sensor/SHT/: sht20.c
    ./driver/iic/: iic_conf.c
    ./driver/vs10xx/: vs10xx.c
    ./driver/vs10xx/decode/: mp3_decode.c
    ./driver/adc/: adc.c
  group main
    ./main/: main.c sys_conf.c
    ./include/: pro_conf.h
  group lib
    ./lib/: arm_cortexM4lf_math.lib
    ./lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
    ./lib/STM32F4xx_HAL_Driver/Src/Legacy/: stm32f4xx_hal_can.c
  group rtt_nano/kernal
    ./thirdParty/rt-thread-nano-sorted/: cpuport.c context_rvds.S
    ./thirdParty/rt-thread-nano-sorted/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt_nano/msh
    ./thirdParty/rt-thread-nano-sorted/finsh/: cmd.c msh.c shell.c
  group rtt_nano/user
    ./thirdParty/rt-thread-nano-sorted/: board.c rtconfig.h user_cmd.c
  group fatfs14
    ./thirdParty/ff14/source/: diskio.c ff.c ff_user.c ffsystem.c ffunicode.c ffconf.h ff_devices.c
  group lvgl/src
    ./thirdParty/lvgl/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./thirdParty/lvgl/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./thirdParty/lvgl/lvgl/src/lv_font/: lv_font.c lv_font_loader.c lv_font_fmt_txt.c lv_font_dejavu_16_persian_hebrew.c
    ./thirdParty/lvgl/lvgl/src/lv_gpu/: lv_gpu_stm32_dma2d.c
    ./thirdParty/lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./thirdParty/lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./thirdParty/lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ./thirdParty/lvgl/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lvgl/port
    ./thirdParty/lvgl/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl/user
    ./thirdParty/lvgl/: lv_conf.h
    ./thirdParty/lvgl/lvgl/font/: ariblk_12.c ariblk_14.c ariblk_16.c ariblk_36_num.c mp3_bg.c
  group lvgl/font
    ./thirdParty/lvgl/lvgl/src/lv_font/: lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group app/src
    ./app/: app_main.c app_task.c app_ui.c
  group app/ui
    ./app/app_ui/: app_calculator.c app_calendar.c app_env.c app_folder.c app_mainmenu.c app_music.c app_setting.c app_status_bar.c
